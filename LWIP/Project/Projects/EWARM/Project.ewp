# IAR project Project.ewp, settings and files
configuration Project Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F439NI ST STM32F439NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_STM324x9I_EVAL; STM32F439xx
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Middlewares\Third_Party\LwIP\system; ..\..\Middlewares\Third_Party\LwIP\src\include; ..\..\Middlewares\Third_Party\LwIP\src\include\ipv4; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Middlewares\Third_Party\LwIP\system\arch; ..\..\Middlewares\Third_Party\LwIP\src\include\ipv4\lwip; ..\..\Middlewares\Third_Party\LwIP\src\include\lwip; ..\..\Middlewares\Third_Party\LwIP\src\include\netif; ..\..\Middlewares\Third_Party\LwIP\src\include\posix; ..\..\Middlewares\Third_Party\LwIP\src\include\posix\sys; ..\..\Middlewares\Third_Party\LwIP\src\netif\ppp; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f439xx.s startup_stm32f439xx.s startup_stm32f439xx.s startup_stm32f439xx.s
  group Application/User
    ../../Src/: ethernetif.c lwip.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c ethernetif.c lwip.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c ethernetif.c lwip.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c ethernetif.c lwip.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_eth.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_eth.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_eth.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Middlewares/LwIP
    ../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c tcpip.c api_msg.c err.c netifapi.c netbuf.c netdb.c api_lib.c sockets.c tcpip.c api_msg.c err.c netifapi.c netbuf.c netdb.c api_lib.c sockets.c tcpip.c api_msg.c err.c netifapi.c netbuf.c netdb.c api_lib.c sockets.c
    ../../Middlewares/Third_Party/LwIP/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c mib2.c asn1_dec.c msg_in.c msg_out.c mib_structs.c asn1_enc.c mib2.c asn1_dec.c msg_in.c msg_out.c mib_structs.c asn1_enc.c mib2.c asn1_dec.c msg_in.c msg_out.c mib_structs.c asn1_enc.c
    ../../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c lcp.c auth.c randm.c ppp_oe.c ipcp.c md5.c magic.c fsm.c ppp.c chpms.c chap.c pap.c vj.c lcp.c auth.c randm.c ppp_oe.c ipcp.c md5.c magic.c fsm.c ppp.c chpms.c chap.c pap.c vj.c lcp.c auth.c randm.c ppp_oe.c ipcp.c md5.c magic.c fsm.c ppp.c chpms.c chap.c pap.c vj.c
    ../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c ip_addr.c ip_frag.c autoip.c igmp.c inet.c inet_chksum.c ip.c icmp.c ip_addr.c ip_frag.c autoip.c igmp.c inet.c inet_chksum.c ip.c icmp.c ip_addr.c ip_frag.c autoip.c igmp.c inet.c inet_chksum.c ip.c icmp.c
    ../../Middlewares/Third_Party/LwIP/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c def.c dns.c memp.c tcp.c tcp_in.c udp.c mem.c netif.c init.c tcp_out.c lwip_timers.c stats.c sys.c raw.c pbuf.c dhcp.c def.c dns.c memp.c tcp.c tcp_in.c udp.c mem.c netif.c init.c tcp_out.c lwip_timers.c stats.c sys.c raw.c pbuf.c dhcp.c def.c dns.c memp.c tcp.c tcp_in.c udp.c mem.c netif.c init.c tcp_out.c lwip_timers.c stats.c sys.c raw.c pbuf.c
    ../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c slipif.c etharp.c slipif.c etharp.c slipif.c etharp.c slipif.c
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
