<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Project Configuration</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f439xx.s</name>
      </file>
    </group>
    <group>
      <name>User</name>
      <file>
        <name>$PROJ_DIR$\..\..\Src\ethernetif.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Src\lwip.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Src\stm32f4xx_hal_msp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Src\stm32f4xx_it.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Drivers</name>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\system_stm32f4xx.c</name>
      </file>
    </group>
    <group>
      <name>STM32F4xx_HAL_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_cortex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_eth.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ramfunc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pwr_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc_ex.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Middlewares</name>
    <group>
      <name>LwIP</name>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\api\api_lib.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\api\api_msg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\snmp\asn1_dec.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\snmp\asn1_enc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\netif\ppp\auth.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\ipv4\autoip.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\netif\ppp\chap.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\netif\ppp\chpms.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\def.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\dhcp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\dns.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\api\err.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\netif\etharp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\netif\ppp\fsm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\ipv4\icmp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\ipv4\igmp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\ipv4\inet.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\ipv4\inet_chksum.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\ipv4\ip.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\ipv4\ip_addr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\ipv4\ip_frag.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\netif\ppp\ipcp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\netif\ppp\lcp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\lwip_timers.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\netif\ppp\magic.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\netif\ppp\md5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\memp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\snmp\mib2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\snmp\mib_structs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\snmp\msg_in.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\snmp\msg_out.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\api\netbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\api\netdb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\netif.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\api\netifapi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\netif\ppp\pap.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\pbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\netif\ppp\ppp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\netif\ppp\ppp_oe.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\netif\ppp\randm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\raw.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\netif\slipif.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\api\sockets.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\stats.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\sys.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\tcp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\tcp_in.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\tcp_out.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\api\tcpip.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\core\udp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Middlewares\Third_Party\LwIP\src\netif\ppp\vj.c</name>
      </file>
    </group>
  </group>
</project>


