<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Timer_F4_PWM_Input.ewp</path>
  </project>
  <batchBuild />
</workspace>
