# IAR project Project_F0.ewp, settings and files
configuration Project_F0 Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072VB ST STM32F072VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F072xB
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project_F0 Configuration.out
  ILINK.IlinkIcfFile: stm32f072xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f072xb.s startup_stm32f072xb.s startup_stm32f072xb.s startup_stm32f072xb.s startup_stm32f072xb.s startup_stm32f072xb.s startup_stm32f072xb.s startup_stm32f072xb.s startup_stm32f072xb.s startup_stm32f072xb.s startup_stm32f072xb.s startup_stm32f072xb.s startup_stm32f072xb.s
  group Application/User
    ../../Src/: HID_Application.c main.c stm32f0xx_hal_msp.c stm32f0xx_it.c usb_device.c usbd_conf.c usbd_desc.c stm32f0xx_hal_msp.c main.c stm32f0xx_it.c usbd_conf.c usb_device.c usbd_desc.c stm32f0xx_hal_msp.c main.c stm32f0xx_it.c usbd_conf.c usb_device.c usbd_desc.c stm32f0xx_hal_msp.c main.c stm32f0xx_it.c usbd_conf.c usb_device.c usbd_desc.c stm32f0xx_hal_msp.c main.c stm32f0xx_it.c usbd_conf.c usb_device.c usbd_desc.c stm32f0xx_hal_msp.c main.c stm32f0xx_it.c usbd_conf.c usb_device.c usbd_desc.c stm32f0xx_hal_msp.c main.c stm32f0xx_it.c usbd_conf.c usb_device.c usbd_desc.c stm32f0xx_hal_msp.c main.c stm32f0xx_it.c usbd_conf.c usb_device.c usbd_desc.c stm32f0xx_hal_msp.c main.c stm32f0xx_it.c usbd_conf.c usb_device.c usbd_desc.c stm32f0xx_hal_msp.c main.c stm32f0xx_it.c usbd_conf.c usb_device.c usbd_desc.c stm32f0xx_hal_msp.c main.c stm32f0xx_it.c usbd_conf.c usb_device.c usbd_desc.c stm32f0xx_hal_msp.c main.c stm32f0xx_it.c usbd_conf.c usb_device.c usbd_desc.c stm32f0xx_hal_msp.c main.c stm32f0xx_it.c usbd_conf.c usb_device.c usbd_desc.c
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_dma.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c usbd_ioreq.c usbd_ctlreq.c usbd_core.c usbd_ioreq.c usbd_ctlreq.c usbd_core.c usbd_ioreq.c usbd_ctlreq.c usbd_core.c usbd_ioreq.c usbd_ctlreq.c usbd_core.c usbd_ioreq.c usbd_ctlreq.c usbd_core.c usbd_ioreq.c usbd_ctlreq.c usbd_core.c usbd_ioreq.c usbd_ctlreq.c usbd_core.c usbd_ioreq.c usbd_ctlreq.c usbd_core.c usbd_ioreq.c usbd_ctlreq.c usbd_core.c usbd_ioreq.c usbd_ctlreq.c usbd_core.c usbd_ioreq.c usbd_ctlreq.c usbd_core.c usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c usbd_hid.c usbd_hid.c usbd_hid.c usbd_hid.c usbd_hid.c usbd_hid.c usbd_hid.c usbd_hid.c usbd_hid.c usbd_hid.c usbd_hid.c usbd_hid.c
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
  group Middlewares/
    ./: 
